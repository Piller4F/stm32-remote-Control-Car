# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test.cpp +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\iic;..\HARDWARE\mpu6050;..\HARDWARE\mpu6050;..\HARDWARE\dmp;..\HARDWARE\hc06;..\HARDWARE\hc06;..\HARDWARE\echo;..\HARDWARE\hongwai;..\HARDWARE\pid;..\HARDWARE\tb6612;..\HARDWARE\timer;..\HARDWARE\ubzzer;..\HARDWARE\remote;..\USER;..\HARDWARE\8x8led
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: test.c car.c
  group HARDWARE
    ../HARDWARE/iic/: iic.c
    ../HARDWARE/mpu6050/: mpu6050.c
    ../HARDWARE/dmp/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/hc06/: hc06.c
    ../HARDWARE/8x8led/: 88led.c
    ../HARDWARE/echo/: echo.c
    ../HARDWARE/hongwai/: hongwai.c
    ../HARDWARE/pid/: pid.c
    ../HARDWARE/remote/: remote.c
    ../HARDWARE/tb6612/: tb6612.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/ubzzer/: buzzer.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
